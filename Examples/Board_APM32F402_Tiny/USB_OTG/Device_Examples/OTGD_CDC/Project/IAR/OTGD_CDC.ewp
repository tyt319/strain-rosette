# IAR project OTGD_CDC.ewp, settings and files
configuration APM32F402 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F402xB Geehy APM32F402xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_DAL_DRIVER; APM32F402xx; BOARD_APM32F402_TINY
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Libraries\APM32F4xx_DAL_Driver\Include; ..\..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include; ..\..\Include; ..\..\Config\Include; ..\..\..\..\..\..\..\Boards\Board_APM32F402_Tiny\Include; ..\..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Core\Inc; ..\..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Class\CDC\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OTGD_CDC.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APM32F4xx_DAL_Driver
    ../../../../../../../Libraries/APM32F4xx_DAL_Driver/Source/: apm32f4xx_dal.c apm32f4xx_dal_cortex.c apm32f4xx_dal_dma.c apm32f4xx_dal_dma_ex.c apm32f4xx_dal_eint.c apm32f4xx_dal_flash.c apm32f4xx_dal_flash_ex.c apm32f4xx_dal_gpio.c apm32f4xx_dal_pcd.c apm32f4xx_dal_pcd_ex.c apm32f4xx_dal_pmu.c apm32f4xx_dal_pmu_ex.c apm32f4xx_dal_rcm.c apm32f4xx_dal_rcm_ex.c apm32f4xx_ddl_usb.c
  group Application
    ../../Source/: apm32f4xx_int.c main.c
  group Application/USB_DEV/App
    ../../Source/: usb_device_user.c usbd_cdc_vcp.c usbd_descriptor.c
  group Application/USB_DEV/Config
    ../../Source/: usbd_board.c
  group Board
    ../../../../../../../Boards/Board_APM32F402_Tiny/Source/: board_apm32f402_tiny.c
  group CMSIS
    ./: startup_apm32f402xx.s
    ../../Source/: system_apm32f4xx.c
  group Config
    ../../Config/Include/: apm32f4xx_dal_cfg.h
    ../../Config/Source/: apm32f4xx_device_cfg.c apm32f4xx_gpio_cfg.c apm32f4xx_nvic_cfg.c apm32f4xx_rcm_cfg.c apm32f4xx_usb_cfg.c
  group Document
    ../../: readme.txt
  group Middlewares/USB_Device_Library
    ../../../../../../../Middlewares/APM32_USB_Library/Device/Core/Src/: usbd_core.c usbd_dataXfer.c usbd_stdReq.c
  group Middlewares/USB_Device_Library/Class
    ../../../../../../../Middlewares/APM32_USB_Library/Device/Class/CDC/Src/: usbd_cdc.c
