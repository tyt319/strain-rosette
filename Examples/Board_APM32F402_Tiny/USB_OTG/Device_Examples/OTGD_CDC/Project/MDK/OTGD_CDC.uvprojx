# Keil uVision project OTGD_CDC.uvprojx, settings and files
target APM32F402 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: APM32F402RB Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.7
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OTGD_CDC
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_DAL_DRIVER, APM32F402xx, BOARD_APM32F402_TINY
  c misc: --gnu
  c include: ..\..\Include;..\..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\..\Libraries\APM32F4xx_DAL_Driver\Include;..\..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include;..\..\..\..\..\..\..\Boards\Board_APM32F402_Tiny\Include;..\..\Config\Include;..\..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Core\Inc;..\..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Class\CDC\Inc;..\..\MyDriver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../Source/: system_apm32f4xx.c
    ./: startup_apm32f402xx.s
  group APM32F4xx_DAL_Driver
    ../../../../../../../Libraries/APM32F4xx_DAL_Driver/Source/: apm32f4xx_dal.c apm32f4xx_dal_cortex.c apm32f4xx_dal_dma.c apm32f4xx_dal_dma_ex.c apm32f4xx_dal_eint.c apm32f4xx_dal_flash.c apm32f4xx_dal_flash_ex.c apm32f4xx_dal_gpio.c apm32f4xx_dal_pmu.c apm32f4xx_dal_pmu_ex.c apm32f4xx_dal_rcm.c apm32f4xx_dal_rcm_ex.c apm32f4xx_dal_pcd.c apm32f4xx_dal_pcd_ex.c apm32f4xx_ddl_usb.c apm32f4xx_dal_adc.c apm32f4xx_dal_adc_ex.c apm32f4xx_dal_can.c apm32f4xx_dal_crc.c apm32f4xx_dal_eth.c apm32f4xx_dal_gpio_ex.c apm32f4xx_dal_hcd.c apm32f4xx_dal_i2c.c apm32f4xx_dal_i2s.c apm32f4xx_dal_irda.c apm32f4xx_dal_iwdt.c apm32f4xx_dal_rtc.c apm32f4xx_dal_rtc_ex.c apm32f4xx_dal_sdram.c apm32f4xx_dal_smbus.c apm32f4xx_dal_spi.c apm32f4xx_dal_tmr.c apm32f4xx_dal_tmr_ex.c apm32f4xx_dal_uart.c apm32f4xx_dal_usart.c apm32f4xx_dal_wwdt.c
  group Board
    ../../../../../../../Boards/Board_APM32F402_Tiny/Source/: board_apm32f402_tiny.c
  group Config
    ../../Config/Include/: apm32f4xx_dal_cfg.h
    ../../Config/Source/: apm32f4xx_device_cfg.c apm32f4xx_rcm_cfg.c apm32f4xx_gpio_cfg.c apm32f4xx_nvic_cfg.c apm32f4xx_usb_cfg.c apm32f4xx_spi_cfg.c apm32f4xx_dma_cfg.c
  group Application
    ../../Source/: apm32f4xx_int.c main.c
  group Application/USB_DEV/App
    ../../Source/: usb_device_user.c usbd_descriptor.c usbd_cdc_vcp.c
  group Application/USB_DEV/Config
    ../../Source/: usbd_board.c
  group MyDriver
    ../../MyDriver/: ads131m08.c bridge_cal.c
  group Middlewares/USB_Device_Library
    ../../../../../../../Middlewares/APM32_USB_Library/Device/Core/Src/: usbd_core.c usbd_dataXfer.c usbd_stdReq.c
  group Middlewares/USB_Device_Library/Class
    ../../../../../../../Middlewares/APM32_USB_Library/Device/Class/CDC/Src/: usbd_cdc.c
  group Document
    ../../: readme.txt
